# Keil uVision project Fly_Test_Source_Code.uvprojx, settings and files
target Fly_Test_Source_Code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fly_Test_Source_Code +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\Lib\src;.\Startup;.\User;.\Hardware;.\Hardware\oled;.\Hardware\device;.\Hardware\MQTT;.\Hardware\onenet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./Startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Lib
    ./Lib/src/: stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c
  group User
    ./User/: stm32f10x_it.c Headfile.h main.c USART.c NVIC.c Bling.c Moto_PWM.c IIC.c MPU6050.c Time.c SPL06_001.c Filter.c SINS.c IMU.c Control.c PPM.c PID.c Calibartion.c FLASH.c US_100.c US_100.h
  group Hardware
    ./Hardware/oled/: bmp.h oled.c oled.h oledfont.h
    ./Hardware/device/: esp8266.c esp8266.h
    ./Hardware/MQTT/: MqttKit.c MqttKit.h
    ./Hardware/onenet/: onenet.c onenet.h
